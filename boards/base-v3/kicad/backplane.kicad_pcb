# Repository winkleplex10-bit/The-Mac-Pro-Project

File README.md:

# MacPro6,2

An open PCB redesign of the Mac Pro (Late 2013, "trashcan"). It keeps the enclosure, the triangular thermal core, the fan and the stock 450 W PSU, and replaces every board with new ones.

- `docs/`: the architecture spec (v0.2), the face module spec, the lineup research, the stock hardware reference and the service references
- `boards/`: current boards (cpu-am5, base-v3, io, ssd, gpu-placeholder)
- `power/`, `firmware/`: current PSU/power and firmware docs
- `archive/`: superseded and parked work
- `mechanical/`: board outlines (DXF), scan traces and 3D-print test parts

Status: early design. The CPU board is AM5 v4 (Ryzen 7000/9000, 1.6 mm 1080A; LGA1700 archived) with an Apple-style contact frame. The faces are an open module spec (GPU on Face P, storage on Face S).

## Current status
See [docs/STATUS-2026-10-29.md](docs/STATUS-2026-10-29.md) (2026-10-29: J1 pinned, boot drive dropped, no NDA parts, base board fab push), [docs/STATUS-2026-10-28.md](docs/STATUS-2026-10-28.md) (2026-10-28 decisions: GPU on hold, Gen5 TI redrivers, SSD board A only) and [docs/STATUS-2026-10-26.md](docs/STATUS-2026-10-26.md) (AM5 baseline, firmware, power, thermal, connector research).

## KiCad design boards/base-v3/kicad/backplane.kicad_pcb

File boards/base-v3/kicad/README.md (part):

# MacPro6,2 backplane (BP) - KiCad 9 project, rev v3 (6 layers, slot B x4; rev A1 4L history below)

## 2026-10-28 ≈15:10 EDT: Gen5 redrivers placed (Aidan decision), board NOT clean
- Added U20 DS320PR1601 (GPU x16; outline-only ZDG0354A placeholder, balls not transcribed), U21/U22 DS320PR810 (SSD FS 0-3 / 4-7, NJX0064A footprint from SNLS668 p.35), U23 PT5161L ALT (DNP, no pads, NDA), 31 decaps + 17 straps/pull-downs on B.Cu (C40-C72, R101-R117). Scripts: tools/rdrv_footprints.py, rdrv_model.py, rdrv_sch.py, rdrv_pcb.py. Backup: /workspace/backups/bp-v3-redrivers-20261028/.
- HS nets *_A/*_B are not yet spliced into FP_*/FS_*; the new parts sit on existing routed copper. drc_report_rdrv_20261028.txt: 437 violations (all new-part vs existing copper), 76 unconnected (new nets), 199 parity entries (U20 placeholder has no pads). ERC: 0 errors, 191 dangling-label warnings (HS split pending). Reroute required. 3V3_RDRV source TBD.
- Rev 7a (≈16:00 EDT): U20 at (173.7,102.9), U21 (158.6,102.9), U22 (152.5,102.9); real ZDG0354A ball map (354 pads, from SNLS683 p.41 vector data); unconnected-* nets set for NC pins. Segment lengths (octilinear): docs/gen5_redriver_segment_lengths_2026-10-28.csv. Details: /workspace/docs/interboard-bandwidth-map.md rev 7.

## Rev v3 (2026-10-09, routed on 6 layers, slot B full x4)

- **Stackup:** 6L JLC06161H-2116, 1.6 mm, ENIG. Layers: L1 `L1_SIG_RX` (RX microstrip), L2 `L2_GND`, L3 `L3_SIG_TX_PWR` (TX stripline + `L3_3V3_SB` plane, y >= 116.2), L4 `L4_SIG_SLOTB` (new slot-B layer), L5 `L5_GND`, L6 `L6_GND_BRK` (GND + low-speed breakout). Through vias 0.45 / 0.25 only. Clearance 0.1 mm (0.15 mm for power).
- **Impedance** (`docs/impedance_v3_6L.json`, `tools/zsolve.py`):
  - L1/L6 85 Ω pairs: 85.5 Ω (w 0.26 / gap 0.125).
  - Existing v1 L3 TX pairs keep their geometry: 88.7–89.7 Ω, within ±10 %.
  - New L3/L4 pairs: 84.5–85.7 Ω (w 0.24 / gap 0.127).
- **Slot B (J1 → J10), lanes 4–7 + REFCLK1.** Intra-pair skew is 0.000 mm on all nine pairs, with 0 P/N issues (`work/pairchk.py`). Length per net and vias per net:

  | Pair | Length (mm) | Vias per net |
  |---|---|---|
  | REFCLK1 | 32.34 | 4 |
  | RX4 | 38.94 | 0 |
  | RX5 | 69.75 | 3 |
  | RX6 | 44.75 | 0 |
  | RX7 | 40.09 | 2 |
  | TX4 | 49.53 | 3 |
  | TX5 | 57.46 | 3 |
  | TX6 | 65.02 | 4 |
  | TX7 | 42.54 | 2 |

- **Broadside rule:** no low-speed track on L3 sits over L4 high-speed copper, and none on L4 sits under L3 high-speed copper (overlap 0, `work/bside.py`).
- **Copper carried over from v1:** v1 HS/SATA/USB2 copper is item-for-item identical to the slot-B build (v6_E8). The v1 48-pair skew table is unchanged (`work/skew_v1_baseline.txt`).
- **Status:**
  - `backplane.kicad_pcb`: **DRC 0 violations, 0 unconnected, 0 schematic-parity issues** (`drc_report.txt`).
  - **ERC: 0 errors / 0 warnings** (`erc_report.txt`).
  - JLC outputs in `jlc/`: 18 Gerber/drill files (6 copper layers), 44 BOM lines, 143 placed parts, all on F.
  - New parts vs A1: Q12 2N7002, R64 1 k, R65 10 k.
- **Low-speed flow:** the low-speed copper was rebuilt as follows. Step log: `PROGRESS_V3.md`.
  1. Freerouting runs, using `tools/bp_ls6.py` (the `L25=` option allows local L2/L5 routing with 0.6 mm clearance to HS copper).
  2. Single-net clean-up with `tools/bp_fix.py` and `work/reach.py`, a 0.1 mm grid min-cost router.
  3. `bp_post.sh`.
  4. DRC fix-ups, one net at a time.
- **Needs Aidan's approval before ordering:**
  - ICD 3.1 FS-lane reversal.
  - INA226 replacing INA228.
  - J7 M.2 DNP, which sets the BIOS/OpenCore boot location.
  - R27 → R33.
  - RP2350B GPIO re-map (firmware pin-map update, `tools/gpio_map.json`).
  - The U1 / Y1 / U2 moves.
  - Storage-face deviations: D-2X-1 and D-2X-2 (pending), and D-S1.
- **Interface:** ICD v3 is `/workspace/macpro62-interface-control-v3.md` (13 reserved pins).
- **Cost:** `/workspace/macpro62-cost-estimate.md` §11. Excluding the CPU, the change is about +$25–35 (6L fab). Including the CPU, it is about −$52 to +$102.
- **Previews:** `docs/preview_v3_L1.png`, `docs/preview_v3_L3.png`, `docs/preview_v3_L4.png`, `docs/preview_v3_L6.png`.

## Rev A1 (2026-10-04, routed on 4 layers)

- **Stackup:** 4L JLC04161H-7628, 1.6 mm, ENIG (was 6L JLC06161H-2116). L1 `L1_SIG_RX` (host RX, microstrip 85 Ω, 83.1 Ω calc), L2 `L2_GND`, L3 `L3_SIG_TX_PWR` (host TX stripline 86.4 Ω + `L3_3V3_SB` plane), L4 `L4_GND_BRK` (GND + low-speed breakout). Through vias 0.45 / 0.25 only. Impedance: `docs/impedance_A1.json`; loss budget: `docs/loss_budget_A1.md`. Gen5 redrivers removed (Gen4 loss 9.5–16.8 dB of 28 dB).
- **Status:** `backplane.kicad_pcb` **DRC 0 violations, 0 unconnected, 0 schematic-parity issues** (`drc_report.txt`); **ERC 0 errors / 0 warnings** (`erc_report.txt`). JLC outputs in `jlc/` (16 Gerber/drill files, 44 BOM lines, 140 placed parts, all on F; 152 footprints incl. 9 DNP).
- **High-speed pairs:** all 40 FP/FS PCIe pairs (x16 + x4, TX and RX) + FP/FS REFCLK: intra-pair skew 0.000 mm, 2 vias per net (J1 escape + one layer change). **SATA0_RX** (J7 41/43 → J1): coupled 85 Ω pair, L1 → L3, 29.45 / 29.45 mm, 2/2 vias. **SATA0_TX** (J7 47/49 → J1 A73/A74): coupled pair, L1 stubs → L3 → L1, 27.70 / 27.70 mm, 2/2 vias. **USB2_SPARE** (J1 B79/B80 → J6 13/14): coupled 90 Ω pair, 57.04 / 57.04 mm, 4/4 vias (was 15/12). USB2 (net-by-net routed, skew incl. 1.6 mm per via): USB2_FACEP 78.6/78.3 mm, skew 0.34 mm, 2/2 vias; USB2_FACES 118.0/114.8 mm, skew 0.00 (4/6 vias); USB2_MCU 28.7/28.3 mm, skew −2.7 mm (3/5 vias, could not reach ≤ 1.5 mm).
- **Flow (tools/):** `build_bp.py` → `bp_hs.py` (HS patterns) → `bp_tune.py` (skew → 0; `TUNE_RE`) → Freerouting (low-speed) → `bp_fix.py route` (grid A* clean-up; footprint/board keep-outs dilated `KOD`, NPTH clearance `NPTHC`, SATA/USB2_SPARE protected via `HSX`; `drcfix` mode removes DRC-violating copper) → `bp_pair.py` (coupled-pair centre-line A* router, `PAIR=RX|TX|USB2_SPARE`) and `bp_hand.py` (hand-route spec with clearance check) → `bp_post.sh` / `bp_finish.py` (pours, GND fan-out, DRC) → `bp_clean2.py` (in-process dangling clean-up, refills first) / `bp_island.py` (GND island stitch vias) / `bp_fill.py` → `jlc_out.py`. Skew report `bp_skew.py`, zone report `bp_zreport.py`. Step log: `PROGRESS_A1.md`.
- **Needs Aidan's approval before ordering:** ICD 3.1 FS-lane reversal; INA226 replacing INA228; J7 M.2 DNP (and so the BIOS/OpenCore boot location); R27 → R33; RP2350B GPIO re-assignment (**firmware pin-map update needed**, `tools/gpio_map.json`); the U1 / Y1 / U2 moves.
- Cost: `/workspace/macpro62-cost-estimate.md` §6a (BP q1 $285–450 → $145–230, q5 $450–750 → $260–395).
- Previews: `docs/preview_A1_L1.png` (L1), `docs/preview_A1_L3.png` (L3) (also in `work/`).

## History (floorplan revisions)

Topology: **HUB** (Aidan, 2026-10-01). The CPU board plugs into J1 (Amphenol Mini Cool Edge 224, ME1022410103011, vertical SMT) and the BP routes PCIe x16 to J9 (MCIO 124, Face P) and x4 to J10 (MCIO 124, Face S).

**Floorplan rev A-fp3 (2026-10-01):** uses Aidan's measurements M1 (GPU-board bottom edges ~15 mm above the BP) and M2 (GPU-board planes ~55 mm from the centre). J9/J10 are now **right-angle** MCIO 124 placeholders (`MP62_MCIO_124P_RightAngle_SMT_PLACEHOLDER`, est. ~9-10 mm high; straight plugs are 15.90 mm and do not fit) with the cable exiting radially under each face edge. J1 sits at the **estimated stock riser-slot chord y = -12.6** (TBD, M2b). The M.2, power and harness connectors moved to the PSU side (-y). The previous fp2 (d = 30 assumed) is archived in `variants/hub_fp2_d30_assumed/`.
**fp3a (2026-10-01, CPU-carrier cross-check):** the J1 placeholder had contact A1 at +x with the A row toward +y, which no real Mini Cool Edge has (top view, A row up: A1 is at -x). The placeholder now uses the real contact offsets from the Amphenol card drawing (incl. key F), and **J1 is rotated 180 deg**: A1 stays at disc +x (bay -> face mapping unchanged), the **A row (host TX) faces the PSU side** and the B row (host RX) faces the core. Layer use swaps: host RX on L1, host TX via to L6. Mates `/workspace/kicad/macpro62-cpu-carrier/` J1 fingers. The pre-fix state is in `/workspace/scratch/bp_before_fp3a/`.

**fp6 (2026-10-04 ≈ 09:10 ET, ICD rev 3, O-10 approved by Aidan):** zero-jog straight-straight MCIO cable with **narrow plugs**.
- `tools/hub_floorplan.py`: **J9 r_c 31.2 → 33.0, s −5.2 → +5.0** (origin (20.62, 13.27) → (14.68, 21.75), ≈ 10.4 mm); **J10 r_c 31.5 → 29.5, s −2.0 → +5.0** (origin (−15.74, 18.57) → (−19.28, 12.20), ≈ 7.3 mm). s = +5.0 = module J_PCIE X 47.0 (face spec update 6), so neither cable jogs. Narrow-plug courtyard (±21.6, `make_footprints.py` in the face template): J9–J10 gap 4.28 mm, **J1–J10 2.33 mm**, J1–J9 11.88 mm.
- **J3 (Face P AUX) (0, 51.4) rot 0 → (42.5, 13.5) rot 45** (≈ 55 mm; beyond J9's outer end, Face-P s ≈ −20.5) and **J4 (Face S AUX) (−38.0, 2.5) rot 135 → (−2.5, 43.5) rot 45** (≈ 54 mm; apex wedge, Face-S s ≈ −28.6). A full free-space search found no other GH15 site; each AUX cable runs along its own face's bottom edge above the MCIO ribbon (≈ 56 mm lateral Face P, ≈ 64 mm Face S; lengths M9).
- **U3 (0, 41.6) → (−7.5, 49.0)** (≈ 10.5 mm). Redriver row **U10–U14 +2.5 mm in x** (U14 (−19.35, −3.5) → (−16.85, −3.5), 0.51 mm to J10).
- New F.Cu rule areas `MCIO_RIBBON_J9` / `MCIO_RIBBON_J10` (no footprints/pads) from the courtyard outer edge to n 63, s ± 21.6.
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
Schematic: backplane.kicad_sch, MP62 backplane rev A1 (BP-G4 cost-down)

Parts:
C1, C5, C8, C9, C12, C14, C16, C19, C21, C22, C23, C24, C25, C26, C27, C28, C32, C33, C34, C35, C38, C39, C83: 100nF 16V X7R 0402; C_0402_1005Metric; LCSC C1525
C2, C3, C4, C6, C7, C10, C11, C13, C15: 22uF 25V X5R 0805; C_0805_2012Metric; LCSC C45783
C20: 1uF 25V X5R 0402; C_0402_1005Metric; LCSC C52923
C29, C30, C31: 4.7uF 10V X5R 0402; C_0402_1005Metric; LCSC C23733
C36, C37: 15pF 50V C0G 0402; C_0402_1005Metric; LCSC C1548
C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C62, C63, C64, C65, C67, C68, C69, C70, C84: 100nF 16V X7R 0402; C_0402_1005Metric
C56, C57, C58, C59, C66, C71: 1uF 10V X5R 0402; C_0402_1005Metric
C60, C61, C72: 10uF 10V X5R 0805; C_0805_2012Metric
C73, C74: 10uF 25V X5R 0805; C_0805_2012Metric
C75: 100nF 25V X7R 0402; C_0402_1005Metric
C76: 100nF 16V X7R 0402 (VBST); C_0402_1005Metric
C77, C78, C79: 22uF 10V X5R 0805; C_0805_2012Metric
C80: 22nF 25V X7R 0402 (dVdt, slew TBD); C_0402_1005Metric
C81: 1uF 25V X5R 0402 (IN); C_0402_1005Metric
C82: 10uF 25V X5R 0805 (OUT); C_0805_2012Metric
D1: SS34 3A 40V Schottky SMA; D_SMA; LCSC C8678
D3: SMAJ15A TVS SMA; D_SMA; LCSC C113958
D4, D5: BAT54A (LBAT54ALT1G); SOT-23; LCSC C12743
D6, D7, D8, D10: LED red 0603; LED_0603_1608Metric; LCSC C2286
F1: 3A 1206 fast fuse (0466003.NRHF class); Fuse_1206_3216Metric; LCSC C14165
H1, H2: MountingHole D4 plated (GND); MountingHole_4mm_Pad
H3: M.2 2242 standoff pad (DNP option); MP62_M2_Standoff_SMT_M2_Pad5.0; not fitted
J1: ME1022410103011 Mini Cool Edge 224 (C4941560, 0 s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; MP62_CPULINK_MiniCoolEdge_224P_Vertical_SMT_PLACEHOLDER; LCSC C4941560
J3: BM15B-GHS-TBT (C5305069) Face P AUX; JST_GH_BM15B-GHS-TBT_1x15-1MP_P1.25mm_Vertical; LCSC C5305069
J4: BM15B-GHS-TBT (C5305069) Face S AUX; JST_GH_BM15B-GHS-TBT_1x15-1MP_P1.25mm_Vertical; LCSC C5305069
J8: BM03B-SRSS-TB SWD (DNP); JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical; LCSC C160389; not fitted
J11: MEG300 84501 GPU face (pinout pending GPU Board); Amphenol_MegArray_84501_300P_10x30_P1.27mm_UNVERIFIED
J12: MEG300 84501 SSD face; Amphenol_MegArray_84501_300P_10x30_P1.27mm_UNVERIFIED
J13: MEG300 84501 I/O face (base-iob-megarray.csv); Amphenol_MegArray_84501_300P_10x30_P1.27mm_UNVERIFIED
J14: MCIO 124P RA (C4867471) base end of CPU-board J3 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; MP62_MCIO_124P_Vertical_SMT_TE2360189_PLACEHOLDER
JP1: BENCH: bridges the Hall interlock (open = normal); SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2: 4.7uH 2A 4x4 (SWPA4030S4R7MT); L_Changjiang_FNR4030S; LCSC C57269
L3: 3.3uH 0806 (FNR201610S3R3MT, RP2350 VREG); L_0805_2012Metric; LCSC C167673
L5: 2.2uH Isat>=7A (part TBD; 4x4 fp placeholder); L_Changjiang_FNR4030S
Q1, Q2, Q5, Q6: AO3401A P-MOS; SOT-23; LCSC C15127
Q10, Q11, Q12: 2N7002 N-MOS; SOT-23; LCSC C8545
R1: 33k 1% 0402; R_0402_1005Metric; LCSC C25779
R2, R4, R7, R8, R13, R14, R16, R17, R18, R19, R20, R21, R23, R24, R25, R26, R29, R30, R33, R34, R35, R36, R39, R40, R42, R43, R44, R45, R46, R47, R48, R49, R65: 10k 1% 0402; R_0402_1005Metric; LCSC C25744
R3: 56k 1% 0402; R_0402_1005Metric; LCSC C25796
R5: 100k 1% 0402 (U6 EN, always on); R_0402_1005Metric; LCSC C25741
R6: 100k 1% 0402 (U7 off until the MCU enables 5V_SBY); R_0402_1005Metric; LCSC C25741
R11: 100k 1% 0402; R_0402_1005Metric; LCSC C25741
R22, R31, R32, R41, R58, R60, R61, R64: 1k 1% 0402; R_0402_1005Metric; LCSC C11702
R27, R28, R37, R38, R50, R51, R52, R53: 2.2k 1% 0402; R_0402_1005Metric; LCSC C25879
R56: 10k 1% 0402 (12V LED); R_0402_1005Metric; LCSC C25744
R57: 10k 1% 0402 (11V_SB LED); R_0402_1005Metric; LCSC C25744
R59, R62, R63: 33R 1% 0402; R_0402_1005Metric; LCSC C25105
R100: 10mR 1% 1W 1206 shunt; R_1206_3216Metric; LCSC C105362
R101: 6.2k 1% 0402 (MODE=L2 target, SNLS683 Tbl 5-1: 6.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; R_0402_1005Metric
R102, R103, R104, R105, R106, R107, R108, R109: TBD strap (SNLS683 Tbl 7-3/8-1); R_0402_1005Metric
R110: 10k 1% 0402 (PD pull-down, GPU redriver on); R_0402_1005Metric
R111: 24.9k 1% 0402 (MODE=L2 secondary, SNLS668 Tbl 7-4); R_0402_1005Metric
R112: 1k 1% 0402 (ADDR0=L0); R_0402_1005Metric
R113: 1k 1% 0402 (ADDR1=L0 -> 0x18/0x19); R_0402_1005Metric
R114: 24.9k 1% 0402 (MODE=L2 secondary); R_0402_1005Metric
R115: 8.25k 1% 0402 (ADDR0=L1); R_0402_1005Metric
R116: 1k 1% 0402 (ADDR1=L0 -> 0x1A/0x1B); R_0402_1005Metric
R117: 10k 1% 0402 (PD pull-down, SSD redrivers on); R_0402_1005Metric
R118: 33.2k 1% 0402 (FB top, SLVSE72B Tbl 2); R_0402_1005Metric
R119: 10k 1% 0402 (FB bottom); R_0402_1005Metric
R120: 100k 1% 0402 (EN pull-up, always on); R_0402_1005Metric
R121: 0R 0402 DNP (SSD optional 3V3_SB); R_0402_1005Metric; not fitted
R122: 300R 1% 0402 (ILIM ~5.0 A typ for ~3.5 A load, SL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; R_0402_1005Metric
R123: 100k 1% 0402 (EN/UVLO top); R_0402_1005Metric
R124: 13k 1% 0402 (EN/UVLO bottom, ~10.4 V UVLO - verif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; R_0402_1005Metric
R125: 1.5k 1% 0402 (IMON, gain TBD p.9); R_0402_1005Metric
R126: 10k 1% 0402 (PG pull-up); R_0402_1005Metric
R127: 10k 1% 0402 (IOB_PLT_RST_N pull-down: reset asser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; R_0402_1005Metric
R128: 10k 1% 0402 (IOB USB OC# A pull-up); R_0402_1005Metric
R129: 10k 1% 0402 (IOB USB OC# C pull-up); R_0402_1005Metric
SW1: BOOTSEL (TS-1187A); SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
SW2: BENCH power button (TS-1187A); SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
U1: RP2350B QFN-80 (C42415655); QFN-80-1EP_10x10mm_P0.4mm_EP3.4x3.4mm; LCSC C42415655
U2: W25Q128JVSIQ (C97521, basic); SOIC-8_5.3x5.3mm_P1.27mm; LCSC C97521
U3: TMP1075DGKR @0x48 core side (C2864807); VSSOP-8_3x3mm_P0.65mm; LCSC C2864807
U4: TMP1075DGKR @0x49 PSU side (C2864807); VSSOP-8_3x3mm_P0.65mm; LCSC C2864807
U5: INA226AIDGSR @0x40 (C49851); VSSOP-10_3x3mm_P0.5mm; LCSC C49851
U6: TPS563201DDCR (C116592) -> 3V3_SB; SOT-23-6; LCSC C116592
U7: TPS563201DDCR (C116592) -> 5V_SBY; SOT-23-6; LCSC C116592
U8: SN74LVC1G74DCUR thermal latch (C70285); VSSOP-8_2.3x2mm_P0.5mm; LCSC C70285
U20: DS320PR1601ZDGR; TI_ZDG0354A_nFBGA-354_22.9x8.9mm; MPN DS320PR1601ZDGR
U21, U22: DS320PR810NJXR; TI_NJX0064A_WQFN-64_5.5x10mm_P0.4mm_EP4.1x8.6mm; MPN DS320PR810NJXR
U24: TPS565208DDCR; SOT-23-6
U25: TPS259824LNRGE; TI_RGE0024M_VQFN-24_4x4mm_P0.5mm_2EP
U26: TMP1075DGKR @0x4A U20 redriver temp, A1=V+ (C2864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; VSSOP-8_3x3mm_P0.65mm; LCSC C2864807
U27: TCA6408APWR I2C GPIO expander @0x20 (IOB sideband); TSSOP-16_4.4x5mm_P0.65mm
Y1: 12MHz 3225 crystal 20pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9002

Connections:
3V3_AUX_P: C13.1, C14.1, J3.1 (3V3_AUX), J3.2 (3V3_AUX), Q1.3 (D), R26.2, R27.2, R28.2, R29.2, R30.2, R31.2
3V3_AUX_S: C15.1, C16.1, J4.1 (3V3_AUX), J4.2 (3V3_AUX), Q2.3 (D), R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R65.2
3V3_RDRV: C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C77.1, C78.1, C79.1, L5.2, R118.1, U20.AC17 (VCC1), U20.AC20 (VCC1), U20.AK17 (VCC1), U20.AK20 (VCC1), U20.AU17 (VCC1), U20.AU20 (VCC2), U20.BD17 (VCC2), U20.BD20 (VCC2), U20.BL17 (VCC2), U20.BL20 (VCC2), U20.BV17 (VCC2), U20.BV20 (VCC2), U20.CE17 (VCC2), U20.CE20 (VCC3), U20.CM17 (VCC3), U20.CM20 (VCC3), U20.CW17 (VCC3), U20.CW20 (VCC3), U20.DF17 (VCC3), U20.DF20 (VCC3), U20.DN17 (VCC3), U20.DN20 (VCC4), U20.DY17 (VCC4), U20.DY20 (VCC4), U20.EG17 (VCC4), U20.EG20 (VCC4), U20.EP17 (VCC4), U20.EP20 (VCC4), U20.T17 (VCC1), U20.T20 (VCC1), U21.6 (VCC), U21.18 (VCC), U21.38 (VCC), U21.50 (VCC), U22.6 (VCC), U22.18 (VCC), U22.38 (VCC), U22.50 (VCC)
3V3_SB: C1.1, C6.1, C7.1, C19.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C38.1, C83.1, C84.1, D10.2 (A), J1.A93 (VIN_PWR_OK), J1.B93 (UART0_TX), J13.J13, J13.J14, J13.J16, J13.J17, JP1.1, L1.2, Q1.2 (S), Q2.2 (S), Q5.2 (S), Q6.2 (S), R1.1, R7.2, R8.2, R13.2, R14.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R23.2, R24.2, R25.2, R33.2, R34.2, R35.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R59.1, R121.1, R126.1, R128.2, R129.2, U1.5 (IOVDD), U1.15 (IOVDD), U1.24 (IOVDD), U1.29 (IOVDD), U1.41 (IOVDD), U1.50 (IOVDD), U1.59 (ADC_AVDD), U1.60 (IOVDD), U1.64 (VREG_VIN), U1.68 (USB_OTP_VDD), U1.69 (QSPI_IOVDD), U1.76 (IOVDD), U2.8 (VCC), U3.8 (V+), U4.7 (A0), U4.8 (V+), U5.6 (VS), U8.8 (VCC), U26.6 (A1), U26.8 (V+), U27.1 (VCCI), U27.3 (RESET), U27.16 (VCCP)
5V_SBY: C10.1, C11.1, J1.A94 (GND), J1.A95 (PLTRST#), J1.A96 (THERMTRIP#), J1.B94 (GND), J1.B95 (UART0_RX), J1.B96 (FAN_PWMOUT), L2.2, R3.1
12V_MAIN_IN: C73.1, C74.1, C75.1, C82.1, D1.2 (A), D8.2 (A), R120.1, U24.3 (VIN), U25.17 (OUT), U25.18 (OUT), U25.19 (OUT), U25.20 (OUT), U25.21 (OUT), U25.22 (OUT), U25.23 (OUT), U25.24 (OUT)
AUXP_EN_N: Q1.1 (G), R7.1, U1.37 (GPIO29)
AUXS_EN_N: Q2.1 (G), R8.1, U1.19 (GPIO19)
BOOTSEL_N: R61.2, SW1.1
BP_12V_IMON: R125.1, U25.9 (IMON)
BP_12V_PG: R126.2, U25.13 (PG)
BP_OTEMP_N: D5.2 (K2), R21.1, U3.3 (ALERT), U4.3 (ALERT), U26.3 (ALERT)
BST_3V3_RDRV: C76.1, U24.6 (VBST)
BST_3V3_SB: C5.1, U6.6 (VBST)
BST_5V_SBY: C9.1, U7.6 (VBST)
CB_CARRIER_HOT_N: J1.A89 (SUS_S3#), R44.1, U1.13 (GPIO14)
CB_FAN_PWM: J1.B88 (GND), U1.6 (GPIO8)
CB_FAN_TACH: J1.B89 (BIOS_SEL), U1.2 (GPIO5)
CB_I2C0_SCL: J1.B84 (GND), R50.1, U1.80 (GPIO3)
CB_I2C0_SDA: J1.B85 (GND), R51.1, U1.79 (GPIO2)
CB_PLTRST_N: J1.A87 (FS_PET5_N), R22.1, R32.1, R64.1, U1.54 (GPIO43)
CB_PWRBTN_N: J14.A29 (REFCLK1+), R42.1, U1.57 (GPIO46)
CB_PWR_ALERT_N: J1.B91 (GND), R43.1, U1.12 (GPIO13)
CB_RSMRST_N: J1.A85 (GND), U1.16 (GPIO16)
CB_SMB_ALERT_N: J14.B29 (PERST1), U1.20 (GPIO20)
CB_SUS_S3_N: J1.A83 (FS_PET4_N), U1.21 (GPIO21)
CB_SUS_S45_N: J1.A84 (GND), U1.58 (GPIO47)
CB_THERMTRIP_N: D4.1 (K1), J1.A88 (GND), R18.1
CB_UART0_RX: J1.B87 (FS_PER5_P), U1.78 (GPIO1)
CB_UART0_TX: J1.B86 (FS_PER5_N), U1.77 (GPIO0)
CB_VIN_PWR_OK: J1.A86 (FS_PET5_P), U1.14 (GPIO15)
CB_WAKE_N: J1.A90 (SUS_S4_S5#)
CC_PRSNT1_N: J1.A1 (CC_PRSNT1#), R45.1, U1.53 (GPIO42)
CC_PRSNT2_N: J1.A112 (CC_PRSNT2#), R46.1, U1.11 (GPIO12)
DVDD: C30.1, C31.1, C32.1, C33.1, C34.1, L3.2, U1.10 (DVDD), U1.32 (DVDD), U1.51 (DVDD), U1.65 (VREG_FB)
EFUSE_DVDT: C80.1, U25.15 (dVdt)
EFUSE_EN: R123.2, R124.1, U25.6 (EN/UVLO)
EFUSE_ILIM: R122.1, U25.8 (ILIM)
EFUSE_IN: C81.1, J1.A102 (FS_PET6_N), J1.A103 (GND), J1.A104 (RSTBTN#), J1.A105 (PWR_ALERT#), J1.A106 (GND), J1.A107 (5V_SBY), J1.B102 (FS_REFCLK1_N), J1.B103 (GND), J1.B104 (FS_PER6_N), J1.B105 (FS_PER6_P), J1.B106 (GND), J1.B107 (3V3_SB), R123.1, U25.1 (IN), U25.2 (IN), U25.3 (IN), U25.16 (IN), U25.25 (IN_PAD)
EN_3V3: R5.1, U6.5 (EN)
EN_5V: R6.1, U1.40 (GPIO32), U7.5 (EN)
FB_3V3_RDRV: R118.2, R119.1, U24.4 (VFB)
FB_3V3_SB: R1.2, R2.1, U6.4 (VFB)
FB_5V_SBY: R3.2, R4.1, U7.4 (VFB)
FP_HOLD: Q10.1 (G), R23.1, U1.36 (GPIO28)
FP_LEDA: D6.2 (A), R31.1
FP_MCIO_PRSNT_N: R24.1
FP_MOD_LED_N: D6.1 (K), J3.15 (MOD_LED#)
FP_PERST_N: Q10.3 (D), R22.2
FP_PRSNT_N: J3.4 (FACE_PRSNT#), R25.1, U1.42 (GPIO33)
FP_PWR_EN: J3.5 (FACE_PWR_EN), U1.49 (GPIO40_ADC0)
FP_PWR_GOOD: J3.6 (FACE_PWR_GOOD), R26.1, U1.43 (GPIO34)
FP_REFCLK_N: J1.A52 (FP_REFCLK_N)
FP_REFCLK_P: J1.A51 (FP_REFCLK_P)
FP_RX0_N: J1.B49 (FP_PER0_N), U20.P29 (A_PETn0)
FP_RX0_N_B: U20.N34 (B_PERn0)
FP_RX0_P: J1.B48 (FP_PER0_P), U20.M26 (A_PETp0)
FP_RX0_P_B: U20.R35 (B_PERp0)
FP_RX1_N: J1.B46 (FP_PER1_N), U20.AA29 (A_PETn1)
FP_RX1_N_B: U20.Y34 (B_PERn1)
FP_RX1_P: J1.B45 (FP_PER1_P), U20.W26 (A_PETp1)
FP_RX1_P_B: U20.AB35 (B_PERp1)
FP_RX2_N: J1.B43 (FP_PER2_N), U20.AH29 (A_PETn2)
FP_RX2_N_B: U20.AJ35 (B_PERn2)
FP_RX2_P: J1.B42 (FP_PER2_P), U20.AF26 (A_PETp2)
FP_RX2_P_B: U20.AG34 (B_PERp2)
FP_RX3_N: J1.B40 (FP_PER3_N), U20.AR29 (A_PETn3)
FP_RX3_N_B: U20.AT35 (B_PERn3)
FP_RX3_P: J1.B39 (FP_PER3_P), U20.AN26 (A_PETp3)
FP_RX3_P_B: U20.AP34 (B_PERp3)
FP_RX4_N: J1.B37 (FP_PER4_N), U20.BB29 (A_PETn4)
FP_RX4_N_B: U20.BA34 (B_PERn4)
FP_RX4_P: J1.B36 (FP_PER4_P), U20.AY26 (A_PETp4)
FP_RX4_P_B: U20.BC35 (B_PERp4)
FP_RX5_N: J1.B34 (FP_PER5_N), U20.BJ29 (A_PETn5)
FP_RX5_N_B: U20.BH34 (B_PERn5)
FP_RX5_P: J1.B33 (FP_PER5_P), U20.BG26 (A_PETp5)
FP_RX5_P_B: U20.BK35 (B_PERp5)
FP_RX6_N: J1.B31 (FP_PER6_N), U20.BT29 (A_PETn6)
FP_RX6_N_B: U20.BU35 (B_PERn6)
FP_RX6_P: J1.B30 (FP_PER6_P), U20.BP26 (A_PETp6)
FP_RX6_P_B: U20.BR34 (B_PERp6)
FP_RX7_N: J1.B27 (FP_PER7_N), U20.CC29 (A_PETn7)
FP_RX7_N_B: U20.CD35 (B_PERn7)
FP_RX7_P: J1.B26 (FP_PER7_P), U20.CA26 (A_PETp7)
FP_RX7_P_B: U20.CB34 (B_PERp7)
FP_RX8_N: J1.B24 (FP_PER8_N), U20.CK29 (A_PETn8)
FP_RX8_N_B: U20.CJ34 (B_PERn8)
FP_RX8_P: J1.B23 (FP_PER8_P), U20.CH26 (A_PETp8)
FP_RX8_P_B: U20.CL35 (B_PERp8)
FP_RX9_N: J1.B21 (FP_PER9_N), U20.CU29 (A_PETn9)
FP_RX9_N_B: U20.CT34 (B_PERn9)
FP_RX9_P: J1.B20 (FP_PER9_P), U20.CR26 (A_PETp9)
FP_RX9_P_B: U20.CV35 (B_PERp9)
FP_RX10_N: J1.B18 (FP_PER10_N), U20.DD29 (A_PETn10)
FP_RX10_N_B: U20.DE35 (B_PERn10)
FP_RX10_P: J1.B17 (FP_PER10_P), U20.DB26 (A_PETp10)
FP_RX10_P_B: U20.DC34 (B_PERp10)
FP_RX11_N: J1.B15 (FP_PER11_N), U20.DL29 (A_PETn11)
FP_RX11_N_B: U20.DM35 (B_PERn11)
FP_RX11_P: J1.B14 (FP_PER11_P), U20.DJ26 (A_PETp11)
FP_RX11_P_B: U20.DK34 (B_PERp11)
FP_RX12_N: J1.B12 (FP_PER12_N), U20.DV29 (A_PETn12)
FP_RX12_N_B: U20.DU34 (B_PERn12)
FP_RX12_P: J1.B11 (FP_PER12_P), U20.DT26 (A_PETp12)
FP_RX12_P_B: U20.DW35 (B_PERp12)
FP_RX13_N: J1.B9 (FP_PER13_N), U20.EE29 (A_PETn13)
FP_RX13_N_B: U20.ED34 (B_PERn13)
FP_RX13_P: J1.B8 (FP_PER13_P), U20.EC26 (A_PETp13)
FP_RX13_P_B: U20.EF35 (B_PERp13)
FP_RX14_N: J1.B6 (FP_PER14_N), U20.EM29 (A_PETn14)
FP_RX14_N_B: U20.EN35 (B_PERn14)
FP_RX14_P: J1.B5 (FP_PER14_P), U20.EK26 (A_PETp14)
FP_RX14_P_B: U20.EL34 (B_PERp14)
FP_RX15_N: J1.B3 (FP_PER15_N), U20.EW29 (A_PETn15)
FP_RX15_N_B: U20.EY35 (B_PERn15)
FP_RX15_P: J1.B2 (FP_PER15_P), U20.EU26 (A_PETp15)
FP_RX15_P_B: U20.EV34 (B_PERp15)
FP_SMB_ALERT_N: J3.10 (FACE_SMB_ALERT#), R29.1, U1.44 (GPIO35)
FP_SMB_SCL: J3.8 (FACE_SMB_CLK), R27.1, U1.56 (GPIO45)
FP_SMB_SDA: J3.9 (FACE_SMB_DAT), R28.1, U1.55 (GPIO44)
FP_THERM_ALERT_N: J3.11 (THERM_ALERT#), R30.1, U1.23 (GPIO23)
FP_THERM_TRIP_N: D4.2 (K2), J3.12 (THERM_TRIP#), R19.1
FP_TX0_N: J1.A49 (FP_PET0_N), U20.R1 (A_PERn0)
FP_TX0_N_B: U20.M7 (B_PETn0)
FP_TX0_P: J1.A48 (FP_PET0_P), U20.N2 (A_PERp0)
FP_TX0_P_B: U20.P10 (B_PETp0)
FP_TX1_N: J1.A46 (FP_PET1_N), U20.AB1 (A_PERn1)
FP_TX1_N_B: U20.W7 (B_PETn1)
FP_TX1_P: J1.A45 (FP_PET1_P), U20.Y2 (A_PERp1)
FP_TX1_P_B: U20.AA10 (B_PETp1)
FP_TX2_N: J1.A43 (FP_PET2_N), U20.AG2 (A_PERn2)
FP_TX2_N_B: U20.AF7 (B_PETn2)
FP_TX2_P: J1.A42 (FP_PET2_P), U20.AJ1 (A_PERp2)
FP_TX2_P_B: U20.AH10 (B_PETp2)
FP_TX3_N: J1.A40 (FP_PET3_N), U20.AP2 (A_PERn3)
FP_TX3_N_B: U20.AN7 (B_PETn3)
FP_TX3_P: J1.A39 (FP_PET3_P), U20.AT1 (A_PERp3)
FP_TX3_P_B: U20.AR10 (B_PETp3)
FP_TX4_N: J1.A37 (FP_PET4_N), U20.BC1 (A_PERn4)
FP_TX4_N_B: U20.AY7 (B_PETn4)
FP_TX4_P: J1.A36 (FP_PET4_P), U20.BA2 (A_PERp4)
FP_TX4_P_B: U20.BB10 (B_PETp4)
FP_TX5_N: J1.A34 (FP_PET5_N), U20.BK1 (A_PERn5)
FP_TX5_N_B: U20.BG7 (B_PETn5)
FP_TX5_P: J1.A33 (FP_PET5_P), U20.BH2 (A_PERp5)
FP_TX5_P_B: U20.BJ10 (B_PETp5)
FP_TX6_N: J1.A31 (FP_PET6_N), U20.BR2 (A_PERn6)
FP_TX6_N_B: U20.BP7 (B_PETn6)
FP_TX6_P: J1.A30 (FP_PET6_P), U20.BU1 (A_PERp6)
FP_TX6_P_B: U20.BT10 (B_PETp6)
FP_TX7_N: J1.A27 (FP_PET7_N), U20.CB2 (A_PERn7)
FP_TX7_N_B: U20.CA7 (B_PETn7)
FP_TX7_P: J1.A26 (FP_PET7_P), U20.CD1 (A_PERp7)
FP_TX7_P_B: U20.CC10 (B_PETp7)
FP_TX8_N: J1.A24 (FP_PET8_N), U20.CL1 (A_PERn8)
FP_TX8_N_B: U20.CH7 (B_PETn8)
FP_TX8_P: J1.A23 (FP_PET8_P), U20.CJ2 (A_PERp8)
FP_TX8_P_B: U20.CK10 (B_PETp8)
FP_TX9_N: J1.A21 (FP_PET9_N), U20.CV1 (A_PERn9)
FP_TX9_N_B: U20.CR7 (B_PETn9)
FP_TX9_P: J1.A20 (FP_PET9_P), U20.CT2 (A_PERp9)
FP_TX9_P_B: U20.CU10 (B_PETp9)
FP_TX10_N: J1.A18 (FP_PET10_N), U20.DC2 (A_PERn10)
FP_TX10_N_B: U20.DB7 (B_PETn10)
FP_TX10_P: J1.A17 (FP_PET10_P), U20.DE1 (A_PERp10)
FP_TX10_P_B: U20.DD10 (B_PETp10)
FP_TX11_N: J1.A15 (FP_PET11_N), U20.DK2 (A_PERn11)
FP_TX11_N_B: U20.DJ7 (B_PETn11)
FP_TX11_P: J1.A14 (FP_PET11_P), U20.DM1 (A_PERp11)
FP_TX11_P_B: U20.DL10 (B_PETp11)
FP_TX12_N: J1.A12 (FP_PET12_N), U20.DW1 (A_PERn12)
FP_TX12_N_B: U20.DT7 (B_PETn12)
FP_TX12_P: J1.A11 (FP_PET12_P), U20.DU2 (A_PERp12)
FP_TX12_P_B: U20.DV10 (B_PETp12)
FP_TX13_N: J1.A9 (FP_PET13_N), U20.EF1 (A_PERn13)
FP_TX13_N_B: U20.EC7 (B_PETn13)
FP_TX13_P: J1.A8 (FP_PET13_P), U20.ED2 (A_PERp13)
FP_TX13_P_B: U20.EE10 (B_PETp13)
FP_TX14_N: J1.A6 (FP_PET14_N), U20.EL2 (A_PERn14)
FP_TX14_N_B: U20.EK7 (B_PETn14)
FP_TX14_P: J1.A5 (FP_PET14_P), U20.EN1 (A_PERp14)
FP_TX14_P_B: U20.EM10 (B_PETp14)
FP_TX15_N: J1.A3 (FP_PET15_N), U20.EV2 (A_PERn15)
FP_TX15_N_B: U20.EU7 (B_PETn15)
FP_TX15_P: J1.A2 (FP_PET15_P), U20.EY1 (A_PERp15)
FP_TX15_P_B: U20.EW10 (B_PETp15)
FS_CLKREQ0_N: J12.A3
FS_CLKREQ1_N: J12.A9, R65.1
FS_HOLD: Q11.1 (G), Q12.1 (G), R33.1, U1.17 (GPIO17)
FS_LEDA: D7.2 (A), R41.1
FS_MCIO_PRSNT_N: R34.1
FS_MOD_LED_N: D7.1 (K), J4.15 (MOD_LED#)
FS_PERST1_N: J12.A7, Q12.3 (D), R64.2
FS_PERST_N: J12.A1, Q11.3 (D), R32.2
FS_PEWAKE0_N: J12.A5
FS_PEWAKE1_N: J12.A11
FS_PRSNT_N: J4.4 (FACE_PRSNT#), R35.1, U1.9 (GPIO11)
FS_PWR_EN: J4.5 (FACE_PWR_EN), U1.1 (GPIO4)
FS_PWR_GOOD: J4.6 (FACE_PWR_GOOD), R36.1, U1.7 (GPIO9)
FS_REFCLK1_N: J1.B79 (USB2_SPARE_P), J12.C29
FS_REFCLK1_P: J1.B78 (GND), J12.C28
FS_REFCLK_N: J1.A79 (RSVD_HS_A2_P), J12.C26
FS_REFCLK_P: J1.A78 (GND), J12.C25
FS_RX0_N: J1.B55 (FS_PER7_N), U21.42 (TX4N)
FS_RX0_N_B: J12.E2, U21.14 (RX4N)
FS_RX0_P: J1.B54 (FS_PER7_P), U21.43 (TX4P)
FS_RX0_P_B: J12.E1, U21.13 (RX4P)
FS_RX1_N: J1.B58 (FS_PER3_P), U21.39 (TX5N)
FS_RX1_N_B: J12.E5, U21.17 (RX5N)
FS_RX1_P: J1.B57 (GND), U21.40 (TX5P)
FS_RX1_P_B: J12.E4, U21.16 (RX5P)
FS_RX2_N: J1.B61 (FS_PER2_P), U21.36 (TX6N)
FS_RX2_N_B: J12.E8, U21.20 (RX6N)
FS_RX2_P: J1.B60 (GND), U21.37 (TX6P)
FS_RX2_P_B: J12.E7, U21.19 (RX6P)
FS_RX3_N: J1.B64 (FS_PER1_P), U21.33 (TX7N)
FS_RX3_N_B: J12.E11, U21.23 (RX7N)
FS_RX3_P: J1.B63 (GND), U21.34 (TX7P)
FS_RX3_P_B: J12.E10, U21.22 (RX7P)
FS_RX4_N: J1.B67 (FS_PER0_P), U22.42 (TX4N)
FS_RX4_N_B: J12.E14, U22.14 (RX4N)
FS_RX4_P: J1.B66 (GND), U22.43 (TX4P)
FS_RX4_P_B: J12.E13, U22.13 (RX4P)
FS_RX5_N: J1.B70 (SATA0_RX_P), U22.39 (TX5N)
FS_RX5_N_B: J12.E17, U22.17 (RX5N)
FS_RX5_P: J1.B69 (GND), U22.40 (TX5P)
FS_RX5_P_B: J12.E16, U22.16 (RX5P)
FS_RX6_N: J1.B73 (USB2_MCU_P), U22.36 (TX6N)
FS_RX6_N_B: J12.E20, U22.20 (RX6N)
FS_RX6_P: J1.B72 (GND), U22.37 (TX6P)
FS_RX6_P_B: J12.E19, U22.19 (RX6P)
FS_RX7_N: J1.B76 (USB2_FACES_P), U22.33 (TX7N)
FS_RX7_N_B: J12.E23, U22.23 (RX7N)
FS_RX7_P: J1.B75 (GND), U22.34 (TX7P)
FS_RX7_P_B: J12.E22, U22.22 (RX7P)
FS_SMB_ALERT_N: J4.10 (FACE_SMB_ALERT#), R39.1, U1.52 (GPIO41)
FS_SMB_SCL: J4.8 (FACE_SMB_CLK), J12.A13, R37.1, U1.4 (GPIO7)
FS_SMB_SDA: J4.9 (FACE_SMB_DAT), J12.A15, R38.1, U1.3 (GPIO6)
FS_THERM_ALERT_N: J4.11 (THERM_ALERT#), R40.1, U1.48 (GPIO39)
FS_THERM_TRIP_N: D5.1 (K1), J4.12 (THERM_TRIP#), R20.1
FS_TX0_N: J1.A55 (FS_PET7_N), U21.2 (RX0N)
FS_TX0_N_B: J12.C2, U21.54 (TX0N)
FS_TX0_P: J1.A54 (FS_PET7_P), U21.1 (RX0P)
FS_TX0_P_B: J12.C1, U21.55 (TX0P)
FS_TX1_N: J1.A58 (FS_PET3_P), U21.5 (RX1N)
FS_TX1_N_B: J12.C5, U21.51 (TX1N)
FS_TX1_P: J1.A57 (GND), U21.4 (RX1P)
FS_TX1_P_B: J12.C4, U21.52 (TX1P)
FS_TX2_N: J1.A61 (FS_PET2_P), U21.8 (RX2N)
FS_TX2_N_B: J12.C8, U21.48 (TX2N)
FS_TX2_P: J1.A60 (GND), U21.7 (RX2P)
FS_TX2_P_B: J12.C7, U21.49 (TX2P)
FS_TX3_N: J1.A64 (FS_PET1_P), U21.11 (RX3N)
FS_TX3_N_B: J12.C11, U21.45 (TX3N)
FS_TX3_P: J1.A63 (GND), U21.10 (RX3P)
FS_TX3_P_B: J12.C10, U21.46 (TX3P)
FS_TX4_N: J1.A67 (FS_PET0_P), U22.2 (RX0N)
FS_TX4_N_B: J12.C14, U22.54 (TX0N)
FS_TX4_P: J1.A66 (GND), U22.1 (RX0P)
FS_TX4_P_B: J12.C13, U22.55 (TX0P)
FS_TX5_N: J1.A70 (FS_REFCLK_P), U22.5 (RX1N)
FS_TX5_N_B: J12.C17, U22.51 (TX1N)
FS_TX5_P: J1.A69 (GND), U22.4 (RX1P)
FS_TX5_P_B: J12.C16, U22.52 (TX1P)
FS_TX6_N: J1.A73 (SATA0_TX_P), U22.8 (RX2N)
FS_TX6_N_B: J12.C20, U22.48 (TX2N)
FS_TX6_P: J1.A72 (GND), U22.7 (RX2P)
FS_TX6_P_B: J12.C19, U22.49 (TX2P)
FS_TX7_N: J1.A76 (RSVD_HS_A1_P), U22.11 (RX3N)
FS_TX7_N_B: J12.C23, U22.45 (TX3N)
FS_TX7_P: J1.A75 (GND), U22.10 (RX3P)
FS_TX7_P_B: J12.C22, U22.46 (TX3P)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, D3.2 (A), H1.1, H2.1, H3.1, J1.A4 (GND), J1.A7 (GND), J1.A10 (GND), J1.A13 (GND), J1.A16 (GND), J1.A19 (GND), J1.A22 (GND), J1.A25 (GND), J1.A28 (GND), J1.A29 (GND), J1.A32 (GND), J1.A35 (GND), J1.A38 (GND), J1.A41 (GND), J1.A44 (GND), J1.A47 (GND), J1.A50 (GND), J1.A53 (GND), J1.A56 (GND), J1.A59 (FS_PET3_N), J1.A62 (FS_PET2_N), J1.A65 (FS_PET1_N), J1.A68 (FS_PET0_N), J1.A71 (FS_REFCLK_N), J1.A74 (SATA0_TX_N), J1.A77 (RSVD_HS_A1_N), J1.A80 (RSVD_HS_A2_N), J1.A92 (RSMRST_OUT#), J1.A97 (GND), J1.A98 (CARRIER_HOT#), J1.A99 (WAKE0#), J1.A100 (GND), J1.A101 (FS_PET6_P), J1.A108 (5V_SBY), J1.A109 (GND), J1.A110 (5V_SBY), J1.A111 (5V_SBY), J1.B1 (GND), J1.B4 (GND), J1.B7 (GND), J1.B10 (GND), J1.B13 (GND), J1.B16 (GND), J1.B19 (GND), J1.B22 (GND), J1.B25 (GND), J1.B28 (GND), J1.B29 (GND), J1.B32 (GND), J1.B35 (GND), J1.B38 (GND), J1.B41 (GND), J1.B44 (GND), J1.B47 (GND), J1.B50 (GND), J1.B53 (GND), J1.B56 (GND), J1.B59 (FS_PER3_N), J1.B62 (FS_PER2_N), J1.B65 (FS_PER1_N), J1.B68 (FS_PER0_N), J1.B71 (SATA0_RX_N), J1.B74 (USB2_MCU_N), J1.B77 (USB2_FACES_N), J1.B80 (USB2_SPARE_N), J1.B81 (GND), J1.B82 (FS_PER4_P), J1.B83 (FS_PER4_N), J1.B90 (I2C0_CLK), J1.B92 (I2C0_DAT), J1.B97 (GND), J1.B98 (FAN_TACHIN), J1.B99 (PWRBTN#), J1.B100 (GND), J1.B101 (FS_REFCLK1_P), J1.B108 (3V3_SB), J1.B109 (GND), J1.B110 (5V_SBY), J1.B111 (5V_SBY), J1.B112 (GND), J1.BL (BOARDLOCK), J3.3 (GND), J3.7 (GND), J3.MP, J4.3 (GND), J4.7 (GND), J4.MP, J8.2 (GND), J8.MP, J12.A2, J12.A4, J12.A6, J12.A8, J12.A10, J12.A12, J12.A14, J12.A16, J12.A18, J12.A20, J12.A22, J12.A24, J12.A26, J12.A28, J12.A30, J12.B1, J12.B2, J12.B3, J12.B4, J12.B5, J12.B6, J12.B7, J12.B8, J12.B9, J12.B10, J12.B11, J12.B12, J12.B13, J12.B14, J12.B15, J12.B16, J12.B17, J12.B18, J12.B19, J12.B20, J12.B21, J12.B22, J12.B23, J12.B24, J12.B25, J12.B26, J12.B27, J12.B28, J12.B29, J12.B30, J12.C3, J12.C6, J12.C9, J12.C12, J12.C15, J12.C18, J12.C21, J12.C24, J12.C27, J12.C30, J12.D1, J12.D2, J12.D3, J12.D4, J12.D5, J12.D6, J12.D7, J12.D8, J12.D9, J12.D10, J12.D11, J12.D12, J12.D13, J12.D14, J12.D15, J12.D16, J12.D17, J12.D18, J12.D19, J12.D20, J12.D21, J12.D22, J12.D23, J12.D24, J12.D25, J12.D26, J12.D27, J12.D28, J12.D29, J12.D30, J12.E3, J12.E6, J12.E9, J12.E12, J12.E15, J12.E18, J12.E21, J12.E24, J12.E27, J12.E30, J12.F1, J12.F2, J12.F3, J12.F4, J12.F5, J12.F6, J12.F7, J12.F8, J12.F9, J12.F10, J12.F11, J12.F12, J12.F13, J12.F14, J12.F15, J12.F16, J12.F17, J12.F18, J12.F19, J12.F20, J12.F21, J12.F22, J12.F23, J12.F24, J12.F25, J12.F26, J12.F27, J12.F28, J12.F29, J12.F30, J12.G3, J12.G6, J12.G9, J12.G12, J12.G15, J12.G18, J12.G21, J12.G24, J12.G27, J12.G30, J12.H1, J12.H2, J12.H3, J12.H4, J12.H5, J12.H6, J12.H7, J12.H8, J12.H9, J12.H10, J12.H11, J12.H12, J12.H13, J12.H14, J12.H15, J12.H16, J12.H17, J12.H18, J12.H19, J12.H20, J12.H21, J12.H22, J12.H23, J12.H24, J12.H25, J12.H26, J12.H27, J12.H28, J12.H29, J12.H30, J12.I1, J12.I2, J12.I3, J12.I4, J12.I5, J12.I6, J12.I7, J12.I8, J12.I9, J12.I10, J12.I11, J12.I12, J12.I13, J12.I14, J12.I15, J12.I16, J12.I17, J12.I18, J12.I19, J12.I20, J12.I21, J12.I22, J12.I23, J12.I24, J12.I25, J12.I26, J12.I27, J12.I28, J12.I29, J12.I30, J12.J1, J12.J2, J12.J3, J12.J4, J12.J5, J12.J6, J12.J7, J12.J8, J12.J9, J12.J10, J12.J11, J12.J12, J12.J13, J12.J14, J12.J15, J12.J16, J12.J17, J12.J18, J12.J19, J12.J20, J12.J21, J12.J22, J12.J23, J12.J24, J12.J26, J12.J28, J12.J30, J13.A2, J13.A3, J13.A6, J13.A9, J13.A12, J13.A15, J13.A18, J13.A21, J13.A24, J13.A27, J13.A28, J13.A29, J13.B3, J13.B6, J13.B9, J13.B12, J13.B15, J13.B18, J13.B21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
GPU_RDRV_PD: R110.1, U20.FF8 (PD_15-12), U20.FF33 (PD_3-0), U20.FJ6 (PD_11-8), U20.FJ31 (PD_7-4)
HALL_A_N: J13.J10, Q5.1 (G), R13.1
HALL_B_N: J13.J11, Q6.1 (G), R14.1
I2C_BB_SCL: J14.B26 (RSVD), U1.47 (GPIO38)
I2C_BB_SDA: J14.B27 (RSVD), U1.8 (GPIO10)
I2C_SYS_SCL: J13.H2, J13.J19, R52.1, U1.46 (GPIO37), U3.2 (SCL), U4.2 (SCL), U5.5 (SCL), U20.B31 (SCL), U21.62 (RX_DET/SCL), U22.62 (RX_DET/SCL), U26.2 (SCL), U27.14 (SCL)
I2C_SYS_SDA: J13.I2, J13.J20, R53.1, U1.45 (GPIO36), U3.1 (SDA), U4.1 (SDA), U5.4 (SDA), U20.B28 (SDA), U21.63 (GAIN0/SDA), U22.63 (GAIN0/SDA), U26.1 (SDA), U27.15 (SDA)
ILK_A: JP1.2, Q5.3 (D), Q6.3 (D), R11.1, U1.38 (GPIO30)
IOB_ACT_LED: J13.F29, U27.9 (P4)
IOB_ASM_CLKREQ_N: J13.I1, J14.B8 (SMCLK)
IOB_ASM_PERST_N: J13.H1, J14.A11 (REFCLK+)
IOB_ASM_PERX0_N: J13.E17, J14.B33 (PET6N)
IOB_ASM_PERX0_P: J13.E16, J14.B32 (PET6P)
IOB_ASM_PERX1_N: J13.E20, J14.B36 (PET7N)
IOB_ASM_PERX1_P: J13.E19, J14.B35 (PET7P)
IOB_ASM_PERX2_N: J13.E23, J14.B40 (PET8N)
IOB_ASM_PERX2_P: J13.E22, J14.B39 (PET8P)
IOB_ASM_PERX3_N: J13.E26, J14.B43 (PET9N)
IOB_ASM_PERX3_P: J13.E25, J14.B42 (PET9P)
IOB_ASM_PETX0_N: J13.E5, J14.A33 (PER6N)
IOB_ASM_PETX0_P: J13.E4, J14.A32 (PER6P)
IOB_ASM_PETX1_N: J13.E8, J14.A36 (PER7N)
IOB_ASM_PETX1_P: J13.E7, J14.A35 (PER7P)
IOB_ASM_PETX2_N: J13.E11, J14.A40 (PER8N)
IOB_ASM_PETX2_P: J13.E10, J14.A39 (PER8P)
IOB_ASM_PETX3_N: J13.E14, J14.A43 (PER9N)
IOB_ASM_PETX3_P: J13.E13, J14.A42 (PER9P)
IOB_ASM_REFCLK_N: J13.F5, J14.B24 (PET5N)
IOB_ASM_REFCLK_P: J13.F4, J14.B23 (PET5P)
IOB_DPA_AUX_N: J13.A17
IOB_DPA_AUX_P: J13.A16
IOB_DPA_HPD: J13.A1
IOB_DPA_ML0_N: J13.A5
IOB_DPA_ML0_P: J13.A4
IOB_DPA_ML1_N: J13.A8
IOB_DPA_ML1_P: J13.A7
IOB_DPA_ML2_N: J13.A11
IOB_DPA_ML2_P: J13.A10
IOB_DPA_ML3_N: J13.A14
IOB_DPA_ML3_P: J13.A13
IOB_DPB_AUX_N: J13.B8
IOB_DPB_AUX_P: J13.B7
IOB_DPB_HPD: J13.B1
IOB_DPB_ML0_N: J13.A20
IOB_DPB_ML0_P: J13.A19
IOB_DPB_ML1_N: J13.A23
IOB_DPB_ML1_P: J13.A22
IOB_DPB_ML2_N: J13.A26
IOB_DPB_ML2_P: J13.A25
IOB_DPB_ML3_N: J13.B5
IOB_DPB_ML3_P: J13.B4
IOB_DPC_AUX_N: J13.B23
IOB_DPC_AUX_P: J13.B22
IOB_DPC_HPD: J13.C1
IOB_DPC_ML0_N: J13.B11
IOB_DPC_ML0_P: J13.B10
IOB_DPC_ML1_N: J13.B14
IOB_DPC_ML1_P: J13.B13
IOB_DPC_ML2_N: J13.B17
IOB_DPC_ML2_P: J13.B16
IOB_DPC_ML3_N: J13.B20
IOB_DPC_ML3_P: J13.B19
IOB_DPD_AUX_N: J13.C14
IOB_DPD_AUX_P: J13.C13
IOB_DPD_HPD: J13.G1
IOB_DPD_ML0_N: J13.B26
IOB_DPD_ML0_P: J13.B25
IOB_DPD_ML1_N: J13.C5
IOB_DPD_ML1_P: J13.C4
IOB_DPD_ML2_N: J13.C8
IOB_DPD_ML2_P: J13.C7
IOB_DPD_ML3_N: J13.C11
IOB_DPD_ML3_P: J13.C10
IOB_HDMI_CEC: J13.F1
IOB_HDMI_DDC_SCL: J13.D1
IOB_HDMI_DDC_SDA: J13.E1
IOB_LAN1_CLKREQ_N: J13.B2, J14.B11 (PERST)
IOB_LAN1_PERST_N: J13.J1, J14.A26 (CLKREQ1)
IOB_LAN1_PERX_N: J13.F11, J14.B46 (PET10N)
IOB_LAN1_PERX_P: J13.F10, J14.B45 (PET10P)
IOB_LAN1_PETX_N: J13.F8, J14.A46 (PER10N)
IOB_LAN1_PETX_P: J13.F7, J14.A45 (PER10P)
IOB_LAN1_REFCLK_N: J13.F14, J14.A24 (PER5N)
IOB_LAN1_REFCLK_P: J13.F13, J14.A23 (PER5P)
IOB_LAN2_CLKREQ_N: J13.E2, J14.B12 (PRSNT)
IOB_LAN2_PERST_N: J13.C2, J14.A27 (WAKE1)
IOB_LAN2_PERX_N: J13.F20, J14.B52 (PET12N)
IOB_LAN2_PERX_P: J13.F19, J14.B51 (PET12P)
IOB_LAN2_PETX_N: J13.F17, J14.A52 (PER12N)
IOB_LAN2_PETX_P: J13.F16, J14.A51 (PER12P)
IOB_LAN2_REFCLK_N: J13.F23, J14.B49 (PET11N)
IOB_LAN2_REFCLK_P: J13.F22, J14.B48 (PET11P)
IOB_PCIE_WAKE_N: J13.F2, J14.B9 (SMDAT)
IOB_PLT_RST_N: J13.B30, R127.1, U27.4 (P0)
IOB_PRSNT_N: J13.H29, R48.1, U1.22 (GPIO22)
IOB_PWR_LED: J13.E29, U27.7 (P3)
IOB_SLP_S3_N: J13.I29, J14.A8 (CLKREQ)
IOB_SLP_S5_N: J13.A30, J14.A9 (WAKE)
IOB_USB2_1_N: J13.I11
IOB_USB2_1_P: J13.I10
IOB_USB2_2_N: J13.I14
IOB_USB2_2_P: J13.I13
IOB_USB2_3_N: J13.I17
IOB_USB2_3_P: J13.I16
IOB_USB2_4_N: J13.I20
IOB_USB2_4_P: J13.I19
IOB_USB2_5_N: J13.I23
IOB_USB2_5_P: J13.I22
IOB_USB2_6_N: J13.I26
IOB_USB2_6_P: J13.I25
IOB_USB2_7_N: J13.J5
IOB_USB2_7_P: J13.J4
IOB_USB3_1_RX_N: J13.H8, J14.B3 (PET0N)
IOB_USB3_1_RX_P: J13.H7, J14.B2 (PET0P)
IOB_USB3_1_TX_N: J13.H5, J14.A3 (PER0N)
IOB_USB3_1_TX_P: J13.H4, J14.A2 (PER0P)
IOB_USB3_2_RX_N: J13.H14, J14.B6 (PET1N)
IOB_USB3_2_RX_P: J13.H13, J14.B5 (PET1P)
IOB_USB3_2_TX_N: J13.H11, J14.A6 (PER1N)
IOB_USB3_2_TX_P: J13.H10, J14.A5 (PER1P)
IOB_USB3_3_RX_N: J13.H20, J14.B15 (PET2N)
IOB_USB3_3_RX_P: J13.H19, J14.B14 (PET2P)
IOB_USB3_3_TX_N: J13.H17, J14.A15 (PER2N)
IOB_USB3_3_TX_P: J13.H16, J14.A14 (PER2P)
IOB_USB3_4_RX_N: J13.H26, J14.B21 (PET4N)
IOB_USB3_4_RX_P: J13.H25, J14.B20 (PET4P)
IOB_USB3_4_TX_N: J13.H23, J14.A21 (PER4N)
IOB_USB3_4_TX_P: J13.H22, J14.A20 (PER4P)
IOB_USB3_5_RX_N: J13.I8, J14.B18 (PET3N)
IOB_USB3_5_RX_P: J13.I7, J14.B17 (PET3P)
IOB_USB3_5_TX_N: J13.I5, J14.A18 (PER3N)
IOB_USB3_5_TX_P: J13.I4, J14.A17 (PER3P)
IOB_USB_OC_N_A: J13.D30, R128.1, U27.5 (P1)
IOB_USB_OC_N_C: J13.C30, R129.1, U27.6 (P2)
LATCH_CLR_N: C20.1, R16.1, U1.28 (GPIO27), U8.6 (CLR#)
LED11_K: R57.1
LED12_K: D8.1 (K), R56.1
LED_ST_K: D10.1 (K), R58.1
MCU_LED_N: R58.2, U1.18 (GPIO18)
MCU_RUN: C39.1, U1.35 (RUN)
MCU_SWCLK: J8.1 (SWCLK), U1.33 (SWCLK)
MCU_SWDIO: J8.3 (SWDIO), U1.34 (SWDIO)
PS_ON_REQ_N: U1.39 (GPIO31)
PWRBTN_IN_N: J13.C29, R49.1, SW2.1, U1.25 (GPIO24)
QSPI_SCLK: U1.71 (QSPI_SCLK), U2.6 (CLK)
QSPI_SD0: U1.72 (QSPI_SD0), U2.5 (DI(IO0))
QSPI_SD1: U1.74 (QSPI_SD1), U2.2 (DO(IO1))
QSPI_SD2: U1.73 (QSPI_SD2), U2.3 (WP#(IO2))
QSPI_SD3: U1.70 (QSPI_SD3), U2.7 (HOLD#(IO3))
QSPI_SS: R61.1, U1.75 (QSPI_SS), U2.1 (CS#)
RDRV_BUCK_EN: R120.2, U24.5 (EN)
SSD_3V3_SB_OPT: J12.J25, R121.2
SSD_RDRV_PD: R117.1, U21.25 (PD0), U21.26 (PD1), U22.25 (PD0), U22.26 (PD1)
SW_3V3_RDRV: C76.2, L5.1, U24.2 (SW)
SW_3V3_SB: C5.2, L1.1, U6.2 (SW)
SW_5V_SBY: C9.2, L2.1, U7.2 (SW)
SYS_INT_N: J13.B29, J13.J22, R47.1, U1.26 (GPIO25), U5.3 (ALERT)
THERM_LATCH: U1.27 (GPIO26), U8.5 (Q)
TRIP_N: D4.3 (A), D5.3 (A), R17.1, U8.7 (PRE#)
U20_A_ADDR0_7_0: R102.1, U20.B23 (A_ADDR0_7-0)
U20_A_ADDR0_15_8: R106.1, U20.FF5 (A_ADDR0_15-8)
U20_A_ADDR1_7_0: R103.1, U20.G1 (A_ADDR1_7-0)
U20_A_ADDR1_15_8: R107.1, U20.FJ3 (A_ADDR1_15-8)
U20_B_ADDR0_7_0: R104.1, U20.B25 (B_ADDR0_7-0)
U20_B_ADDR0_15_8: R108.1, U20.FJ28 (B_ADDR0_15-8)
U20_B_ADDR1_7_0: R105.1, U20.F34 (B_ADDR1_7-0)
U20_B_ADDR1_15_8: R109.1, U20.FF30 (B_ADDR1_15-8)
U20_MODE: R101.1, U20.FF24 (MODE)
U21_ADDR0: R112.1, U21.59 (EQ0/ADDR0)
U21_ADDR1: R113.1, U21.60 (EQ1/ADDR1)
U21_MODE: R111.1, U21.61 (MODE)
U22_ADDR0: R115.1, U22.59 (EQ0/ADDR0)
U22_ADDR1: R116.1, U22.60 (EQ1/ADDR1)
U22_MODE: R114.1, U22.61 (MODE)
USB2_FACEP_N: J1.B52 (USB2_FACEP_N), J3.14 (USB2_D-)
USB2_FACEP_P: J1.B51 (USB2_FACEP_P), J3.13 (USB2_D+)
USB2_FACES_N: J4.14 (USB2_D-)
USB2_FACES_P: J4.13 (USB2_D+)
USB2_HUB_UP_N: J14.A49 (PER11N)
USB2_HUB_UP_P: J14.A48 (PER11P)
USB2_MCU_N: J1.A82 (FS_PET4_P), R63.2
USB2_MCU_P: J1.A81 (GND), R62.2
USB2_SPARE_N: J13.J8
USB2_SPARE_P: J13.J7
USB_DM_M: R63.1, U1.66 (USB_DM)
USB_DP_M: R62.1, U1.67 (USB_DP)
VIN: C2.1, C3.1, C4.1, C8.1, C12.1, R5.2, R100.2, U5.8 (VBUS), U5.9 (IN-), U6.3 (VIN), U7.3 (VIN)
VIN_F: D3.1 (K), F1.2, R100.1, U5.10 (IN+)
VIN_OR: D1.1 (K), F1.1
VREG_AVDD: C35.1, R59.2, U1.61 (VREG_AVDD)
VREG_LX: L3.1, U1.63 (VREG_LX)
XIN: C36.1, U1.30 (XIN), Y1.1 (X1)
XOUT: R60.1, U1.31 (XOUT)
XOUT_C: C37.1, R60.2, Y1.3 (X2)

Notes on the sheet:
Gen5 redrivers (Aidan 2026-10-28): U20 DS320PR1601 GPU x16 (A side = J1/CPU, B side = GPU face), U21/U22 DS320PR810 SSD x8 (FS lanes 0-3 / 4-7). No NDA parts (Aidan 2026-10-29). High-speed nets *_A / *_B are NOT yet spliced into FP_*/FS_* (J1->J9/J10 copper still direct): net split + reroute pendin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
Rev 7b (Aidan 2026-10-28): PSU is 12 V only; base fed only via J1. U24 TPS565208 (5 A) 12V_MAIN_IN -> 3V3_RDRV for U20-U22 (~10.5 W). J9/J10 MCIO stand-ins set off-board; J11 GPU / J12 SSD MEG-Array faces. NOTE: J1 has no 12 V pins yet (12V_MAIN_IN still enters on J2).
Base 12 V eFuse U25 TPS259824LNRGE (Aidan 2026-10-28: base 12 V from J1 P12V, taken ahead of CB eFuse). EFUSE_IN = J1 v4 P12V pins A103-B106 (x8) - J1 symbol still v3: apply when the v4 J1 pinout freezes. OUT = 12V_MAIN_IN. J2 Micro-Fit now obsolete.
